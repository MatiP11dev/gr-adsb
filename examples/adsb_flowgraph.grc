options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: adsb_flowgraph
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: const
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: gain_variable
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,1)
    start: '0'
    step: '1'
    stop: '150'
    value: gain
  states: {}
- name: low_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0)
    start: '0'
    step: '0.001'
    stop: '0.05'
    value: '0.007'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,0)
    start: '0'
    step: '0.001'
    stop: '0.07'
    value: '0.01'
  states: {}
- name: adsbp11_decoder_0
  id: adsbp11_decoder
  parameters: {}
  states: {}
- name: adsbp11_demod_0
  id: adsbp11_demod
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
    vlen: '112'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: low_threshold
  states: {}
- name: bw
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      ############################################################
      #  ppm_to_bits: 224 muestras (0/1)  ->  vector 112 bits
      #  – supone 2 MS/s  (2 muestras por µs, 1 bit por µs)
      #  – entrada: byte stream con tag  "packet_len = 224"
      #  – salida:  vector<byte,112>  (0/1)  +  copy de tags
      ############################################################
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):          # or basic_block
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="ppm_to_bits",
                  in_sig=[np.uint8],
                  out_sig=[(np.uint8,112)])   # vector len 112

              # Para recoger bursts completos según el tag de longitud
              self.buf = np.array([], dtype=np.uint8)

          def work(self, input_items, output_items):
              IN  = input_items[0]
              OUT = output_items[0]
              n_out = 0

              # Añade nueva entrada al buffer
              if len(IN):
                  self.buf = np.concatenate((self.buf, IN))

              # Procesa mientras haya >=224 muestras en buffer
              while len(self.buf) >= 224:
                  burst = self.buf[:224]
                  self.buf = self.buf[224:]          # descarta procesado

                  # Sub-muestreo: toma la 2ª muestra de cada par [0 1]→bit1
                  bits = burst[1::2].copy()          # 112 bytes 0/1
                  OUT[n_out][:] = bits
                  n_out += 1

                  # Copia la etiqueta corr_start a la salida (opcional)
                  # self.add_item_tag(0, self.nitems_written(0)+n_out-1,
                  #                  pmt.string_to_symbol("burst"), pmt.PMT_NIL)

              return n_out
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np, pmt\nimport datetime\nimport time\nimport json\nimport requests\nfrom gnuradio import gr\n\nPOLY = 0xFFF409           # CRC-24 polinomio ADS-B\nCPR_TIMEOUT_S = 300 # Seconds consider CPR-encoded lat/lon info invalid\npos_cpr=[(0, 0, 0), (0, 0, 0)]\ndef crc24(bits):\n    crc = 0\n    for b in bits[:88]:\n        crc = ((crc << 1) & 0xFFFFFF) ^ (POLY if (b ^ (crc >> 23) & 1) else 0)\n    return crc\ndef calculate_lat_lon(cpr):\n        # If the even and odd frame data is still valid, calculate the\n        # latitude and longitude\n        lat_dec = np.nan\n        lon_dec = np.nan\n\n        if ((int(time.time()) - cpr[0][2]) < CPR_TIMEOUT_S and (int(time.time()) - cpr[1][2]) < CPR_TIMEOUT_S):\n            # Get fractional lat/lon for the even and odd frame\n            # Even frame\n            lat_cpr_even = float(cpr[0][0])/131072\n            lon_cpr_even = float(cpr[0][1])/131072\n\n            # Odd frame\n            lat_cpr_odd = float(cpr[1][0])/131072\n            lon_cpr_odd = float(cpr[1][1])/131072\n\n            # Calculate the latitude index\n            j = int(np.floor(59*lat_cpr_even - 60*lat_cpr_odd + 0.5))\n\n            lat_even = 360.0/60*((j % 60) + lat_cpr_even)\n            if lat_even >= 270:\n                lat_even -= 360\n\n            lat_odd = 360.0/59*((j % 59) + lat_cpr_odd)\n            if lat_odd >= 270:\n                lat_odd -= 360\n\n            # nl_even_old = self.compute_cpr_nl(lat_even)\n            # nl_odd_old = self.compute_cpr_nl(lat_odd)\n\n            nl_even = cpr_nl(lat_even)\n            nl_odd = cpr_nl(lat_odd)\n\n            if nl_even == nl_odd:\n                # Even/odd latitudes are in the same latitude zone, use the\n                # most recent latitude\n                if (cpr[0][2] - cpr[1][2]) > 0:\n                    # The even frame is more recent\n                    lat_dec = lat_even\n\n                    # Calculate longitude\n                    ni = cpr_n(lat_even, 0)\n                    m = int(np.floor(lon_cpr_even*(cpr_nl(lat_even)-1) - lon_cpr_odd*cpr_nl(lat_even) + 0.5))\n                    lon_dec = (360.0/ni)*((m % ni) + lon_cpr_even)\n                    if lon_dec >= 180.0:\n                        lon_dec -= 360.0\n\n                else:\n                    # The odd frame is more recent\n                    lat_dec = lat_odd\n\n                    # Calculate longitude\n                    ni = cpr_n(lat_odd, 1)\n                    m = int(np.floor(lon_cpr_even*(cpr_nl(lat_odd)-1) - lon_cpr_odd*cpr_nl(lat_odd) + 0.5))\n                    lon_dec = (360.0/ni)*((m % ni) + lon_cpr_odd)\n                    if lon_dec >= 180.0:\n                        lon_dec -= 360.0\n\n            # else:\n                # Even/odd latitudes are not in the same latitude zones, wait\n                # for more data\n\n        return (lat_dec, lon_dec)\n\n\ndef cpr_n(lat, frame):\n        # frame = 0, even frame\n        # frame = 1, odd frame\n        n = cpr_nl(lat) - frame;\n\n        if n > 1:\n            return n\n        else:\n            return 1\n\n\ndef compute_cpr_nl(lat):\n        NZ = 60.0\n        # TODO: Might need to tweak this equation\n        return int(2.0*np.pi/(np.arccos(1.0 - (1.0-np.cos(np.pi/(2.0*NZ)))/(np.cos(2.0*np.pi*abs(lat)/180.0)**2))))\n\n\ndef cpr_nl(lat):\n        if lat < 0:\n            lat = -lat\n\n        if lat < 10.47047130:\n            return 59\n        elif lat < 14.82817437:\n            return 58\n        elif lat < 18.18626357:\n            return 57\n        elif lat < 21.02939493:\n            return 56\n        elif lat < 23.54504487:\n            return 55\n        elif lat < 25.82924707:\n            return 54\n        elif lat < 27.93898710:\n            return 53\n        elif lat < 29.91135686:\n            return 52\n        elif lat < 31.77209708:\n            return 51\n        elif lat < 33.53993436:\n            return 50\n        elif lat < 35.22899598:\n            return 49\n        elif lat < 36.85025108:\n            return 48\n        elif lat < 38.41241892:\n            return 47\n        elif lat < 39.92256684:\n            return 46\n        elif lat < 41.38651832:\n            return 45\n        elif lat < 42.80914012:\n            return 44\n        elif lat < 44.19454951:\n            return 43\n        elif lat < 45.54626723:\n            return 42\n        elif lat < 46.86733252:\n            return 41\n        elif lat < 48.16039128:\n            return 40\n        elif lat < 49.42776439:\n            return 39\n        elif lat < 50.67150166:\n            return 38\n        elif lat < 51.89342469:\n            return 37\n        elif lat < 53.09516153:\n            return 36\n        elif lat < 54.27817472:\n            return 35\n        elif lat < 55.44378444:\n            return 34\n        elif lat < 56.59318756:\n            return 33\n        elif lat < 57.72747354:\n            return 32\n        elif lat < 58.84763776:\n            return 31\n        elif lat < 59.95459277:\n            return 30\n        elif lat < 61.04917774:\n            return 29\n        elif lat < 62.13216659:\n            return 28\n        elif lat < 63.20427479:\n            return 27\n        elif lat < 64.26616523:\n            return 26\n        elif lat < 65.31845310:\n            return 25\n        elif lat < 66.36171008:\n            return 24\n        elif lat < 67.39646774:\n            return 23\n        elif lat < 68.42322022:\n            return 22\n        elif lat < 69.44242631:\n            return 21\n        elif lat < 70.45451075:\n            return 20\n        elif lat < 71.45986473:\n            return 19\n        elif lat < 72.45884545:\n            return 18\n        elif lat < 73.45177442:\n            return 17\n        elif lat < 74.43893416:\n            return 16\n        elif lat < 75.42056257:\n            return 15\n        elif lat < 76.39684391:\n            return 14\n        elif lat < 77.36789461:\n            return 13\n        elif lat < 78.33374083:\n            return 12\n        elif lat < 79.29428225:\n            return 11\n        elif lat < 80.24923213:\n            return 10\n        elif lat < 81.19801349:\n            return 9\n        elif lat < 82.13956981:\n            return 8\n        elif lat < 83.07199445:\n            return 7\n        elif lat < 83.99173563:\n            return 6\n        elif lat < 84.89166191:\n            return 5\n        elif lat < 85.75541621:\n            return 4\n        elif lat < 86.53536998:\n            return 3\n        elif lat < 87.00000000:\n            return 2\n        else:\n            return 1\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name=\"adsb_decode\",\n            in_sig=[(np.uint8, 112)],\n            out_sig=[]\n        )\n        self.message_port_register_out(pmt.intern(\"out\"))\n    @staticmethod\n    def bits2int(b):          # lista/ndarray de 0-1 -> int\n        return int(''.join(str(x) for x in b), 2)#cambiando a float\n\n    def work(self, ins, outs):\n        for vec in ins[0]:\n            bits = vec.tolist()\n\n            rx_crc   = self.bits2int(bits[88:])\n            calc_crc = crc24(bits)\n\n            if rx_crc != calc_crc:          # descarta si CRC falla\n                continue\n\n            df   = self.bits2int(bits[0:5])\n            if df not in (17, 11):\n                continue\n\n            icao = '%06X' % self.bits2int(bits[8:32])\n            tc   = self.bits2int(bits[32:37])\n\n            msg = {\"DF\": df, \"ICAO\": icao, \"TC\": tc}\n\n            # Type-code 1–4  → callsign\n            if (df == 17 or df == 11 or df==18) and 1 <= tc <= 4:\n                charset = '#ABCDEFGHIJKLMNOPQRSTUVWXYZ##### ###############0123456789######'\n                cs = ''.join(charset[self.bits2int(bits[40+6*i:46+6*i])] for i in range(8))\n                msg[\"callsign\"] = cs.replace('#', '').strip()\n\n            # Type-code 9-18 → altitud + CPR\n            if df == 17 and 9 <= tc <= 18:\n                alt = self.bits2int(bits[40:52])\n                q   = (alt >> 4) & 1\n                if q:\n                    alt = (((alt & 0xFE0) >> 1) | (alt & 0xF)) * 25 - 1000\n                msg[\"altitude_ft\"] = alt\n                msg[\"even\"]   = bool((tc - 9) % 2 == 0)\n                frame_bit = bits[53]\n                pos_cpr[frame_bit]= (self.bits2int(bits[54:71]), self.bits2int(bits[71:88]), int(time.time()))\n                print(pos_cpr)\n                (lat, lon)=calculate_lat_lon(pos_cpr)\n                msg[\"lat_cp\"] = '%11.7f' % lat\n                msg[\"lon_cp\"] = '%11.7f' % lon\n                data = {\n            \t    \"icao\": icao,\n            \t    \"latitud\": '%11.7f' % lat,\n            \t    \"longitud\": '%11.7f' %lon\n                }\n            if df == 17 and tc == 19:\n                 st=self.bits2int(bits[40:52])\n                 resv_a=bits[41]\n                 nac=self.bits2int(bits[42:45])\n                 s_ew=bits[45]\n                 v_ew=self.bits2int(bits[46:56])\n                 s_ns=bits[56]\n                 v_ns=self.bits2int(bits[57:67])\n                 vr_src=bits[67]\n                 s_vr=bits[68]\n                 vr=self.bits2int(bits[69:78])\n                 resv_b=self.bits2int(bits[78:80])\n                 s_diff=bits[80]\n                 diff=bits[81:88]\n                 #velocity West to East\n                 velocity_we = (v_ew - 1)\n                 # s_ew = 0, flying West ot East\n                 # s_ew = 1, flying East to West\n                 if s_ew == 1:\n                     velocity_we *= -1 # Flip direction\n\n                 # Velocity South to North\n                 velocity_sn = (v_ns - 1)\n                 # s_ns = 0, flying South to North\n                 # s_ns = 1, flying North to South\n                 if s_ns == 1:\n                     velocity_sn *= -1 # Flip direction\n\n                 # Speed (knots)\n                 speed = np.sqrt(velocity_sn**2 + velocity_we**2)\n\n                 # Heading (degrees)\n                 heading = np.arctan2(velocity_sn,velocity_we)*360.0/(2.0*np.pi)\n\n                 # Vertical Rate (ft/min)\n                 vertical_rate = (vr - 1)*64\n                 # s_vr = 0, ascending\n                 # s_vr = 1, descending\n                 if s_vr == 1:\n                     vertical_rate *= -1\n                 msg[\"speed mph\"]='%11.7f' % speed\n                 msg[\"heading\"]='%11.7f' % heading\n                 msg[\"vertical_Rate\"]='%11.7f' % vertical_rate\n                 #try:\n                 #   r = requests.post(\"http://localhost:5000/avion\", json=data)\n                 #except requests.exceptions.RequestException as e:\n                 #   print(e)\n            # envía por puerto de mensajes\n            print(msg)\n            self.message_port_pub(\n                pmt.intern(\"out\"),\n                pmt.to_pmt(msg)\n            )\n            \n\n        return len(ins[0])\n       \n"
  states: {state: disabled}
- name: freq
  id: parameter
  parameters:
    value: 1.09e9
  states: {}
- name: gain
  id: parameter
  parameters:
    value: '70'
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: int(samp_rate/2)
    bbdc: 'True'
    buffer_size: '65536'
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''manual'''
    manual_gain1: gain_variable
    quadrature: 'False'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:10.128.120.6
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '16384'
    gui_hint: (3,1,2,1)
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Threshold"'
    size: '512'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (3,0,2,1)
    name: '"RF IN"'
    size: '1024'
    srate: samp_rate
    tr_level: low_threshold
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '0.020'
    ymin: '-0.002'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Paquete adsb"'
    vlen: '112'
    x_start: '0'
    x_step: '1.0'
    ymax: '1.2'
    ymin: '-0.2'
  states: {}
- name: satlab_digital_correlate_access_code_tag_fixed_0
  id: satlab_digital_correlate_access_code_tag_fixed
  parameters:
    access_code: '1010000101000000'
    pkt_len: '240'
    tagname: '"corr_start"'
    threshold: '2'
  states: {}
- name: soapy_gomspace_source_0
  id: soapy_gomspace_source
  parameters:
    agc: 'False'
    bandwidth: samp_rate
    center_freq: freq
    dev_args: ''
    gain: gain_variable
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    dev_args: uri=ip:192.168.2.1
    gain: gain_variable
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    dc_offs_enb0: auto
    dev_args: recv_frame_size=1472
    gain0: gain_variable
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [adsbp11_decoder_0, out, blocks_message_debug_0, print]
- [adsbp11_demod_0, '0', adsbp11_decoder_0, '0']
- [adsbp11_demod_0, '0', blocks_char_to_float_0, '0']
- [adsbp11_demod_0, '0', epy_block_1, '0']
- [blocks_char_to_float_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_uchar_0, '0', satlab_digital_correlate_access_code_tag_fixed_0, '0']
- [blocks_skiphead_0, '0', adsbp11_demod_0, '0']
- [blocks_skiphead_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_char_to_float_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, out, blocks_message_debug_0, print]
- [satlab_digital_correlate_access_code_tag_fixed_0, '0', blocks_skiphead_0, '0']
- [soapy_gomspace_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1007-gd1fa98fb
